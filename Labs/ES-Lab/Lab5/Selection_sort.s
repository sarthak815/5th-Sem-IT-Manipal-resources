	AREA RESET, DATA, READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0x10001000 
	DCD Reset_Handler 
	
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR r0, =SRC  	  	  	  
  	MOV R2,#10 	  	
  	LDR r3, =DST  		
  	MOV r4,#0  	

DST_COP
	LDR R5,[R0],#4
	STR R5,[R3],#4
	ADD R4,#1
	CMP R4,R2
	BNE DST_COP
	LDR R0,=DST
OUT
	MOV R8,R0;R8=ADDRESS OF MIN ELEMENT
	LDR R5,[R0],#4;R5=VALUE TO BE REPLACED
	SUB R4,#1;R4= OUTER COUNTER
	TEQ R4,#0
	BEQ EXIT
	MOV R7,R0;R7 = ADDRESS TO ITERATE
	MOV R6,R4;R6 = INNER LOOP COUNTER
	B IN

IN	
	LDR R9,[R8];R9 = MIN VALUE
	LDR R10,[R7];R10 = CURRENT VALUE
	CMP R10,R9
	BLE STORE
	ADD R7,#4
	SUB R6,#1
	TEQ R6,#0
	BEQ SWAP
	B IN
	
STORE
	MOV R8,R7
	ADD R7,#4
	SUB R6,#1
	TEQ R6,#0
	BEQ SWAP
	B IN
SWAP
	LDR R7,[R8];R7 = NEW MIN VALUE
	SUB R0,#4
	LDR R6,[R0];R6 = OLD MIN VALUE
	STR R7,[R0],#4
	STR R6,[R8]
	B OUT
EXIT
				
STOP
	B STOP
  
SRC DCD 1,2,5,4,3,9,7,8,0,6
	AREA mydata,DATA,READWRITE  
DST DCD 0
	END  